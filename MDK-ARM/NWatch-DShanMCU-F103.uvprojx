# Keil uVision project NWatch-DShanMCU-F103.uvprojx, settings and files
target NWatch-DShanMCU-F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Nwatch-DShanMCU-F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers/DShanMCU-F103;../NWatch;./RTOS;./ThirdParty/FreeRTOS-Kernel/include;./ThirdParty/FreeRTOS-Kernel/portable/RVDS/ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/DShanMCU-F103
    ../Drivers/DShanMCU-F103/: driver_color_led.c driver_ir_receiver.c driver_irq.c driver_lcd.c driver_oled.c driver_systick.c driver_timer.c driver_uart.c driver_passive_buzzer.c gui_log_console.c driver_dht11.c driver_spiflash_w25q64.c
  group NWatch
    ../NWatch/: alarm.c alarms.c animation.c appconfig.c buttons.c display.c draw.c game1.c game2.c game3.c games.c global.c m_display.c m_main.c menu.c millis.c normal.c pwrmgr.c resources.c settings.c stopwatch.c time.c timedate.c torch.c tune.c tunes.c ui.c watchface.c sound.c sleep.c diag.c tunemaker.c reset.c
  group FreeRTOS-Kernel
    ./ThirdParty/FreeRTOS-Kernel/: tasks.c queue.c list.c
    ./ThirdParty/FreeRTOS-Kernel/portable/RVDS/ARM_CM3/: port.c
    ./ThirdParty/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group RTOS
    ./RTOS/: rtos_app.c sensor.c
software components: CMSIS:CORE 4.3.0
